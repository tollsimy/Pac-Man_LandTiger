# Keil uVision project sample.uvprojx, settings and files
target LandTiget_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: include.h common.h main.c
  group lib_SoC_board
    ./: system_LPC17xx.c
  group led
    ./led/: funct_led.c lib_led.c led.h
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group joystick
    ./joystick/: funct_joystick.c joystick.h lib_joystick.c
  group button
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h
  group adc
    ./adc/: adc.h IRQ_adc.c lib_adc.c
  group pacman
    ./pacman/: pacman.c pacman.h graphic.c play.c ready.c reset.c pacman_IRQ.c can.c pacman_music.c enemy.c
  group CAN
    ./CAN/: CAN.h IRQ_CAN.c lib_CAN.c
  group music
    ./music/: music.c music.h
target SW_Debug (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: sample
  c flags: Optim=2 v6Lang=5 v6LangP=3 wLevel=2
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0
